PACKAGECONFIG = "gadget-schemes libconfig"
