require rk3566-pinned-inputs.inc
SRC_URI[firmware.sha256sum] = "65110f822fdbdd0163ce2dabc60591e7a8a0ffbc9471780e29eef0062f9ed7b6"
