# Microduck uses the library through GStreamer, not ffmpeg-backed file input.
PACKAGECONFIG = ""
