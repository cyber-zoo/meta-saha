PACKAGECONFIG:append = " x264"
