PACKAGECONFIG = "${GSTREAMER_ORC} jpeg libpng v4l2 gudev"
