PACKAGECONFIG = "openssl gstreamer"
