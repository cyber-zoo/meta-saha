PACKAGECONFIG = "${GSTREAMER_ORC} alsa opus"
