FILESEXTRAPATHS:prepend:tegra-saha  := "${THISDIR}/files:"
SPLASH_IMAGES:tegra-saha = "file://psplash-OE4T-img.h;outsuffix=default"
